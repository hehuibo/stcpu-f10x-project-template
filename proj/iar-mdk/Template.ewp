# IAR project Template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: _DEBUG; STM32F10X_MD; USE_STDPERIPH_DRIVER; JLINK_RTT_TRACE; _NoRTOSKernel
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\src\Chip\PeriphDriver\inc; ..\..\src\Chip\STM32F10x\CMSIS; ..\..\src\Chip\STM32F10x\Comm\inc; ..\..\src\Chip\STM32F10x\STM32F10x_StdPeriph_Driver\inc; ..\..\src\Chip\STM32F10x\STM32_USB-FS-Device_Driver\inc; ..\..\src\Comm\utlis\inc; ..\..\src\Comm\utlis\inc\trace; ..\..\src\Comm\utlis\inc\trace\RTT; ..\..\src\Comm\Param\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Template.bin
  ILINK.IlinkOutputFile: cc.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STM32F10X_MD; USE_STDPERIPH_DRIVER; UART_TRACE; _NoRTOSKernel
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\src\Chip\PeriphDriver\inc; ..\..\src\Chip\STM32F10x\CMSIS; ..\..\src\Chip\STM32F10x\Comm\inc; ..\..\src\Chip\STM32F10x\STM32F10x_StdPeriph_Driver\inc; ..\..\src\Chip\STM32F10x\STM32_USB-FS-Device_Driver\inc; ..\..\src\Comm\utlis\inc; ..\..\src\Comm\utlis\inc\trace; ..\..\src\Comm\utlis\inc\trace\RTT; ..\..\src\Comm\Param\inc; ..\..\src\Core\inc\CompositeDev
  group app
    ./: AppCore.c main.c
  group chip/STM32F10x/CMSIS
    ../../src/Chip/STM32F10x/CMSIS/iar/: startup_stm32f10x_md.s
    ../../src/Chip/STM32F10x/CMSIS/: stm32f10x_it.c system_stm32f10x.c
  group chip/STM32F10x/Comm
    ../../src/Chip/STM32F10x/Comm/src/: GPIO.c StartUpCfg.c USART1.c
  group chip/STM32F10x/STM32F10x_StdPeriph_Driver
    ../../src/Chip/STM32F10x/STM32F10x_StdPeriph_Driver/src/: STM32F10xStdPeriphLib.a
  group comm/utils
    ../../src/Comm/utlis/src/: FSMBuffer.c
  group comm/utils/libs
    ../../src/Comm/utlis/src/: libs.c utils.c
  group comm/utils/note
    ../Tools/: iar.txt
  group comm/utils/trace
    ../../src/Comm/utlis/src/trace/: trace.c
    ../../src/Comm/utlis/inc/trace/: trace.h
  group comm/utils/trace/RTT
    ../../src/Comm/utlis/src/trace/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
