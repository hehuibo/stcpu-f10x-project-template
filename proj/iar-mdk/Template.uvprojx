# Keil uVision project Template.uvprojx, settings and files
target Debug (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,_NoRTOSKernel,_DEBUG
  c include: ..\iar-mdk;..\..\src\Chip\PeriphDriver\inc;..\..\src\Chip\STM32F10x\Comm\inc;..\..\src\Chip\STM32F10x\STM32F10x_StdPeriph_Driver\inc;..\..\src\Comm\utlis\inc;..\..\src\Comm\utlis\inc\trace;..\..\src\Comm\utlis\inc\trace\RTT;..\..\src\Core\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ./: appcfg.h AppCore.c main.c main.h stm32f10x_conf.h
  group Chip\STM32F10x\CommDri
    ../../src/Chip/STM32F10x/Comm/src/: GPIO.c SPI.c StartUpCfg.c USART1.c
  group Chip\STM32F10x\CMSIS
    ../../src/Chip/STM32F10x/CMSIS/: stm32f10x_it.c
  group Chip\STM32F10x\StdPeriph_Driver
    ../../src/Chip/STM32F10x/STM32F10x_StdPeriph_Driver/src/: STM32F10xStdPeriphLib.lib
  group Comm\utlis\libs
    ../../src/Comm/utlis/src/: crc.c FSMBuffer.c libs.c utils.c
  group Comm\utlis\trace
    ../../src/Comm/utlis/src/trace/: trace.c
    ../../src/Comm/utlis/src/trace/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
target Release (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: as above
  output: Template
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,_NoRTOSKernel,_DEBUG
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 5.0.2, Device:Startup 1.0.0
